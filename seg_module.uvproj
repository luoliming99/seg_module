# Keil uVision project seg_module.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: seg_module_V1.0.01.000. +hex
  c flags: Optimize=1 SizeSpeed=1
  c include: .\bsp;.\device;.\common;.\application
  group application
    ./application/: STARTUP.A51 main.c disp.c proc.c
  group bsp
    ./bsp/: uart.c timer.c pwm.c
  group common
    ./common/: delay.c
